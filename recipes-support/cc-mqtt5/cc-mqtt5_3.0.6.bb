SRCREV = "06f6e5dd680c536b9c8216fc373548db4837c50b"
require cc-mqtt5.inc

