SRCREV = "e7deda82358a7e5ec219907282050ab70fa28fda"
require cc-mqtt5-nolic.inc
