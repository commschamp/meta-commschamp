SRCREV = "7e7d83ff3a860f1953699d3597a4337b0e55d6db"
require cc-mqttsn-nolic.inc

