SRCREV = "fb8af00966739774a9adf5b380b4c17bd303b523"
require cc-mqttsn-nolic.inc
