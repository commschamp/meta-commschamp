SRCREV = "b65d1e7187e79b35a1b907148dfdb1444b5b8f72"
require cc-comms.inc
