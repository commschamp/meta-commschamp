require cc-comms.inc
