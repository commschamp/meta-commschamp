SRCREV = "cd5c79581d119992b53a4c2ba710343380b27dce"
require cc-comms.inc
