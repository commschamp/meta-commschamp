SRCREV = "ebaa7b6097b74bfa01310556b8e8ef5527afafa2"
require cc-comms.inc
