SRCREV = "923e459e72dd18e0057fdcf4e0963600b59d1b56"
require cc-comms.inc
