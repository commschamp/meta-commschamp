SRCREV = "93453fd03413ba58af1e364e25cfcd7516fb2b74"
require cc-comms.inc
