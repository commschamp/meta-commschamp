SRCREV = "3a58ce05684eb23b169e2e8719e7750230c3a7c5"
require cc-comms.inc
