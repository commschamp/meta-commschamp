SRCREV = "7573cc0c555ab6013d6312f4626735eb81ef78f4"
require cc-comms.inc
