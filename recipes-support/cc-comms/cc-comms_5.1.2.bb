SRCREV = "0c726eb00eb7bf6c79f4a8878cec1439ee456f80"
require cc-comms.inc
