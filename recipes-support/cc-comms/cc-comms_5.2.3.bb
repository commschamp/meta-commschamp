SRCREV = "6cfc9af6ecaf5e6f2b30adfd9ab2a789cbd452a6"
require cc-comms.inc
