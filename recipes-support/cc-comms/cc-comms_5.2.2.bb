SRCREV = "d2aaffcaecd089b548f71db9c615730b57f7364a"
require cc-comms.inc
