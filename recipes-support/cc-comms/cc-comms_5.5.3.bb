SRCREV = "597385fcd9d943ec35bde684d7b2ac947c7f7332"
require cc-comms.inc
