SRCREV = "bbc50c64be3ce39632e5c61bab72cb3fa94d27b7"
require cc-comms.inc
