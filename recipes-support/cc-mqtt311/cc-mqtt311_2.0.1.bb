SRCREV = "5a8be5aac6dad90972dc5300d0ce5feeba8c738b"
require cc-mqtt311-nolic.inc
