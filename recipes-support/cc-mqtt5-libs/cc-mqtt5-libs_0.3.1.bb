SRCREV = "deec71f205be0abc7cf36fc6e55392609f62ab1f"
require cc-mqtt5-libs.inc
