SRCREV = "9baaf6b7c92f88be80ccd23b0bc2d252d5d2b0ad"
require cc-mqtt5-libs.inc
