SRCREV = "db1cf44b14fb7031ccda2c10c10845fe01290572"
require cc-ublox.inc
