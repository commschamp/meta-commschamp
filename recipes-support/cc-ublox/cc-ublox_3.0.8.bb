SRCREV = "4232a11159fd488af69b91b3c6d2a9d05caaf8e6"
require cc-ublox.inc
