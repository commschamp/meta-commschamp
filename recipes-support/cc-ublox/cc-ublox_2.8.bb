SRCREV = "7bf8bb98912692ecf876ab953d53a001829b9aec"
require cc-ublox.inc
