SRCREV = "1bf9afb49d4cfa2df5c5690b058d944ce23e05ba"
require cc-ublox.inc
