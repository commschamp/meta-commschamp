SRCREV = "d8d54ab02ccd4dd12e785dcaf8d496076ba8bf5b"
require cc-ublox.inc
