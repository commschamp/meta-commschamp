SRCREV = "ccef86e8230efb8e7923ff922f183ebfb35bda17"
require cc-ublox-nolic.inc
