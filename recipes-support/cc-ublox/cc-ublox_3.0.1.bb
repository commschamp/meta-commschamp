SRCREV = "b7e739fbd301eb1592106c7c3132a31a82f7f651"
require cc-ublox.inc
