SRCREV = "784e1047eb2f25691bb553b3865e78139b6e6988"
require cc-ublox.inc
