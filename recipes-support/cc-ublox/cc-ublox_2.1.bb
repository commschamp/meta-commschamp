SRCREV = "4c723b5bb6caf86ee60f510a8fd9e69435c2c489"
require cc-ublox-nolic.inc
