SRCREV = "04ef6c62124ef1c757839cd155953b4ebe7fd4b6"
require cc-ublox.inc
