SRCREV = "3f8df8fcdf92b94990e3ee1ea96a498c532eff7b"
require cc-commsdsl.inc
