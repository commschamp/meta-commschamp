SRCREV = "00c09fac4ba8cec5d8af3560f3a92b6103a6d255"
require cc-commsdsl.inc
