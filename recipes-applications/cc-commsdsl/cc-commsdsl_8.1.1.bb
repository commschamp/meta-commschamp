SRCREV = "e39ca3b2d5a1d274601906ce1130b94e20f7ac59"
require cc-commsdsl.inc
