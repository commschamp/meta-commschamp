SRCREV = "0a362f4b2c2f66ff975200f902821b130af2bdf2"
require cc-commsdsl.inc
