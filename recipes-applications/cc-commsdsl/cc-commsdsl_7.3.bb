SRCREV = "340c9ffbfcf7a2db7d478b1802a14ebd09ba1887"
require cc-commsdsl.inc
