SRCREV = "2ed99891c9a521ee76cf18278679ae489f41d3cb"
require cc-commsdsl.inc
