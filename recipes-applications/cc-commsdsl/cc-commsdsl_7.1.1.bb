SRCREV = "862b2c36fc2cb535a170b03844762dc994a2df61"
require cc-commsdsl.inc
