SRCREV = "b2fa93c435c84c1d00d2f4315ad383ee8cbdb819"
require cc-commsdsl.inc
