SRCREV = "db556ba27bbd73cfb516bb865ddb9bc89ed4ebd4"
require cc-commsdsl.inc
