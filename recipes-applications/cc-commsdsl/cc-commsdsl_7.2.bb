SRCREV = "83f6724b73502b3fabc10ad34bfd08287ba7e13c"
require cc-commsdsl.inc
