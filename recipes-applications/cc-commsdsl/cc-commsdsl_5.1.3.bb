SRCREV = "7f986aa6aa780ee3b80738e2cd718b077a50535b"
require cc-commsdsl.inc
