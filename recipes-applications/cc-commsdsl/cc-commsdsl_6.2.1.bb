SRCREV = "b0bf73b68f6f258f61ac4b7bcb00c04c7d79357b"
require cc-commsdsl.inc
