SRCREV = "e40ff6bbff9195ddc6fdbc888b9530be81fe7c4d"
require cc-commsdsl.inc
