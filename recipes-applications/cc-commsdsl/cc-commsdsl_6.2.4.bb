SRCREV = "7a79211f5f5313b6b12719829feffd2c6b02a643"
require cc-commsdsl.inc
