SRCREV = "195e6141ecbd1d0c569f30a6f06383cf89f3759f"
require cc-commsdsl.inc
