SRCREV = "f8685fa98c67752d72dccb0ffd5e3754f6acf068"
require cc-commsdsl.inc
