SRCREV = "14ac9dc0b495fb0ea6106b3c5463a75c7a4fc22f"
require cc-commsdsl.inc
