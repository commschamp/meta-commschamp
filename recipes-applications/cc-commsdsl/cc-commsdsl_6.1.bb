SRCREV = "90139c452df8bb132048cc98bb9b72d8091bc309"
require cc-commsdsl.inc
