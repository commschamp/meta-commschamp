SRCREV = "45ee0d357a0ab0e5002f42105ca91e36d87be70d"
require cc-commsdsl.inc
