require cc-commsdsl.inc
